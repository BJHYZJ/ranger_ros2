Commit message: update

File: ranger_description/urdf/ranger_mini3_v3.urdf (robot description, URDF)
Before this commit: robot ranger_mini_v3, 10 links, 9 joints
Links:
- removed link box_Link
Joints:
- removed joint box_joint
